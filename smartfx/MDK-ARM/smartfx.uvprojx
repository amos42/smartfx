# Keil uVision project smartfx.uvprojx, settings and files
target smartfx (ARM-ADS)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.0
  cpu: IROM(0x08000000-0x080FFFFF) IRAM(0x20000000-0x2004FFFF) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: smartfx +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;..\..\ui\src\BaseDef\inc;..\..\ui\src\SYSAPI\inc;..\..\ui\src\SYSAPI\OEM_inc;..\..\ui\src\UI_Base\A_UIEng\inc;..\..\ui\src\UI_Base\A_UIEng\OEM_inc;..\..\ui\src\UI_Base\Component\BasePkg\inc;..\..\ui\src\UI_Base\Component\ExtPkg\inc;..\..\ui\src\EXT_LIB\A_Util\inc;..\..\ui\src\EXT_LIB\A_Res\inc;..\..\ui\src\EXT_LIB\A_Math\inc;..\..\ui\src\EXT_LIB\GrpX\inc;..\..\ui\src\EXT_LIB\freetype-2.3.9\include;..\..\ui\src\Apps\APP_SmartFx\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0xc0000000 size 0x800000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: adc.c gpio.c dac.c main.c ltdc.c usart.c dma.c usb_otg.c fmc.c sdmmc.c quadspi.c stm32f7xx_it.c stm32f7xx_hal_msp.c stm32f7xx_hal_timebase_TIM.c i2c.c tim.c dma2d.c
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_dma2d.c stm32f7xx_hal_sd.c stm32f7xx_hal_rcc_ex.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_fmc.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_i2c.c stm32f7xx_hal_dma.c stm32f7xx_hal_tim.c stm32f7xx_hal_spi.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_uart.c stm32f7xx_hal_sdram.c stm32f7xx_hal.c stm32f7xx_hal_flash.c stm32f7xx_hal_rcc.c stm32f7xx_hal_qspi.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_adc.c stm32f7xx_hal_dac.c stm32f7xx_hal_gpio.c
  group bsp_n_thread
    ../Src/: bsp_usart.c threads.c bsp_gpio.c bsp_ble.c bsp_key.c bsp_lcd.c bsp_sdram.c bsp_quadspi.c bsp_touch.c bsp_adc.c bsp_dma2d.c bsp_flash.c
  group ui
    ../../ui/src/Apps/APP_SmartFx/src/: APP_Entry.c Global.c MainWnd.c Screen_1_descript.c Screen_1_divid_exam.c Screen_1_question.c Screen_1_recover_exam.c Screen_1_result.c Screen_1_result_2.c Screen_2_control.c Screen_2_descript.c Screen_2_question.c Screen_2_read.c Screen_2_result.c Screen_3_chart.c Screen_3_chart_2.c Screen_3_image.c Screen_3_result.c Screen_3_select.c Screen_calculate.c Screen_information.c Screen_setting.c
  group lib
    ../../ui/__Output/lib/ARMSmartFX/Debug/: liba_math.a liba_util.a liba_res.a libgrpx.a liba_uieng.a libsysapi.a libfreetype.a libcomp_basepkg.a libcomp_extpkg.a
  group OEM_SYSAPI
    ../../ui/src/OEM/SYSAPI_OEM/SmartFX/src/: oem_sa_debug.c oem_sa_key.c oem_sa_mem.c oem_sa_scr.c oem_sa_str.c oem_sa_system.c oem_sa_task.c oem_sa_timer.c oem_sa_touch.c OEM_SYSAPI_init.c
  group ui_entryptr
    ../Src/ui_entryptr/: EntryPtr.h Launcher_EntryPtr.c
  group OEM_AUP
    ../../ui/src/OEM/AUP_OEM/SmartFX/src/: oem_ui_debug_tx.c oem_ui_font_tx.c oem_ui_gdi_win32.c OEM_UI_init.c oem_ui_key_tx.c oem_ui_mem_tx.c oem_ui_proc_tx.c oem_ui_res_tx.c oem_ui_str_win32.c oem_ui_system_winpc.c oem_ui_timer_tx.c oem_ui_touch_win32.c
software components: CMSIS:CORE 5.0.0, CMSIS:DSP 1.4.6, CMSIS:RTOS:Keil RTX 4.81.0
